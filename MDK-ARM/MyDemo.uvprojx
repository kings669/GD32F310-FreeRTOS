# Keil uVision project MyDemo.uvprojx, settings and files
target MyDemo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F310K8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.3.0.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MyDemo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F310
  c include: ..\BSP;..\Core\Inc;..\Drivers\GD32F3x0_standard_peripheral\Include;..\Drivers\CMSIS\GD\GD32F3x0\Include;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\User;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Middlewares\Third_Party\FreeRTOS\Source\portable\MemMang;..\Drivers\CMSIS;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ../Drivers/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
  group Application/User/Core
    ../Core/Src/: main.c gd32f3x0_it.c systick.c gpio.c
  group Drivers/GD32F3x0_Driver
    ../Drivers/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Mddlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/include/: FreeRTOSConfig.h
